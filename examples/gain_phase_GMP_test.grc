options:
  parameters:
    author: Alekh Gupta
    generate_options: qt_gui
    id: Check
    output_language: python
    title: Non-linear_Single_Tone_Setup
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '100'
    stop: '10000'
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitude
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1)
    mode: '0'
    model_param1: '2'
    model_param2: '2'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_PA_0, '0']
- [blocks_throttle_0, '0', dpd_gain_phase_calibrate_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '2']
- [dpd_GMP_model_PA_0, '0', qtgui_time_sink_x_0, '1']
- [dpd_gain_phase_calibrate_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
