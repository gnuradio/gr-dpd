options:
  parameters:
    author: Alekh Gupta
    generate_options: qt_gui
    id: Check
    output_language: python
    title: Non-linear_Single_Tone_Setup
  states: {}

blocks:
- name: amplitude
  id: variable_qtgui_range
  parameters:
    label: Amplitude Shift
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '2'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: Phase Shift
    orient: Qt.Horizontal
    start: '-180'
    step: '1'
    stop: '180'
    value: '90'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amplitude*numpy.exp(1j*phase)
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '3'
    ymin: '-3'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0, '0', dpd_gain_phase_calibrate_0, '0']
- [blocks_multiply_const_vxx_0, '0', dpd_gain_phase_calibrate_0, '2']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle_0, '0', dpd_gain_phase_calibrate_0, '1']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [dpd_gain_phase_calibrate_0, '0', qtgui_time_sink_x_0, '2']

metadata:
  file_format: 1
