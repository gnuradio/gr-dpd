options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: test
    output_language: python
  states: {}

blocks:
- name: param_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '500000'
    value: '7000'
  states: {}
- name: param_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.00075'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: param_1
    freq: param_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: param_1
    freq: '-param_0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (0.87760033+0.12275496j, 0.08798957-0.14373307j, 0.04626261+0.00934458j, 0.08698256+0.04143527j)
    coeff2: (1.3+0.1j)
    mode: Both
    model_param1: '2'
    model_param2: '2'
    model_param3: '1'
    model_param4: '1'
    model_param5: '1'
  states: {}
- name: dpd_GMP_model_PA_1
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (0.87760033+0.12275496j, 0.08798957-0.14373307j, 0.04626261+0.00934458j, 0.08698256+0.04143527j)
    coeff2: (1.3+0.1j)
    mode: Both
    model_param1: '2'
    model_param2: '2'
    model_param3: '1'
    model_param4: '1'
    model_param5: '1'
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    dpd_params: (2,2,1,1,1)
    mode: static
    tap: (0.68 - 0.1j,-0.1+0.1j, 0.12-0.01j,0.2-0.01j, 0.2-0.01j)
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,0,4,1]'
    name: '"PA_without_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,1,4,1]'
    name: '"PA_with_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_PA_1, '0']
- [blocks_throttle_0, '0', dpd_predistorter_training_0, '0']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_2, '0']
- [dpd_GMP_model_PA_1, '0', qtgui_freq_sink_x_1, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']

metadata:
  file_format: 1
