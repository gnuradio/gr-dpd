options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '25000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '1'
    model_param4: '1'
    model_param5: '1'
  states: {}
- name: dpd_RLS_postdistorter_0
  id: dpd_RLS_postdistorter
  parameters:
    dpd_params: (1, 1, 2, 2, 2)
    iter_limit: '10000'
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    M: '9'
  states: {}
- name: dpd_stream_to_gmp_vector_0
  id: dpd_stream_to_gmp_vector
  parameters:
    dpd_params: (1, 1, 2, 2, 2)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '25000'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', dpd_gain_phase_calibrate_0, '1']
- [analog_sig_source_x_0, '0', dpd_stream_to_gmp_vector_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_0, '0']
- [dpd_RLS_postdistorter_0, taps, dpd_predistorter_training_0, taps]
- [dpd_gain_phase_calibrate_0, '0', dpd_RLS_postdistorter_0, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']
- [dpd_predistorter_training_0, '0', dpd_RLS_postdistorter_0, '1']
- [dpd_stream_to_gmp_vector_0, '0', dpd_predistorter_training_0, '0']

metadata:
  file_format: 1
