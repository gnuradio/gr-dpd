options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: '25000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    mode: '0'
    model_param1: '2'
    model_param2: '2'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_RLS_postdistorter_0
  id: dpd_RLS_postdistorter
  parameters:
    dpd_params: (2, 3, 2, 3, 2)
    iter_limit: '1000'
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    M: '18'
  states: {}
- name: dpd_stream_to_gmp_vector_0
  id: dpd_stream_to_gmp_vector
  parameters:
    dpd_params: (2, 3, 2, 3, 2)
  states: {}
- name: dpd_stream_to_message_0
  id: dpd_stream_to_message
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '25000'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', dpd_stream_to_gmp_vector_0, '0']
- [analog_sig_source_x_0, '0', dpd_stream_to_message_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_0, '0']
- [dpd_RLS_postdistorter_0, taps, dpd_predistorter_training_0, taps]
- [dpd_gain_phase_calibrate_0, '0', dpd_RLS_postdistorter_0, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']
- [dpd_predistorter_training_0, PA_input, dpd_RLS_postdistorter_0, PA_input]
- [dpd_stream_to_gmp_vector_0, '0', dpd_predistorter_training_0, '0']
- [dpd_stream_to_message_0, samples, dpd_gain_phase_calibrate_0, samples]

metadata:
  file_format: 1
