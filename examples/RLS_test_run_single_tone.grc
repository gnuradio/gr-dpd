options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: param_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Frequency
    orient: Qt.Horizontal
    start: '0'
    step: '1000'
    stop: '500000'
    value: '10000'
  states: {}
- name: param_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: param_1
    freq: param_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '1'
    model_param4: '1'
    model_param5: '1'
  states: {}
- name: dpd_GMP_model_PA_0_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1)
    coeff2: (1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '1'
    model_param4: '1'
    model_param5: '1'
  states: {}
- name: dpd_RLS_postdistorter_0
  id: dpd_RLS_postdistorter
  parameters:
    dpd_params: (1, 1, 2, 2, 2)
    iter_limit: '1000'
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    dpd_params: (1, 1, 2, 2, 2)
    mode: training
    tap: (1)
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[1,1,4,1]'
    name: '"PA_with_DPD"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[1,0,4,1]'
    name: '"PA_without_DPD"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_sig_source_x_0, '0', dpd_GMP_model_PA_0_0, '0']
- [analog_sig_source_x_0, '0', dpd_gain_phase_calibrate_0, '1']
- [analog_sig_source_x_0, '0', dpd_predistorter_training_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '2']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_0, '0']
- [dpd_GMP_model_PA_0_0, '0', qtgui_freq_sink_x_1, '0']
- [dpd_RLS_postdistorter_0, taps, dpd_predistorter_training_0, taps]
- [dpd_gain_phase_calibrate_0, '0', dpd_RLS_postdistorter_0, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']
- [dpd_predistorter_training_0, '0', dpd_RLS_postdistorter_0, '1']
- [dpd_predistorter_training_0, '1', dpd_RLS_postdistorter_0, '2']

metadata:
  file_format: 1
