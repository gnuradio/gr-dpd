options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: test
    output_language: python
  states: {}

blocks:
- name: param_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '500000'
    value: '7000'
  states: {}
- name: param_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/alekh/gr-dpd/examples/Data_Files/Output.bin
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: gr-dpd/examples/Data_Files/Input.bin
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1.13009008-0.12616218j, -0.09705140+0.15224208j, -0.06966981-0.01212059j, -0.05285608-0.05305477j, 0.04687984-0.00207777j, 0.02600698+0.02553034j)
    coeff2: ( -0.07853527-0.00276647j, 0.08182787+0.0277548j, 0.09832700+0.026040201j, -0.06854425-0.02041091j, -0.04878962-0.01979666j, 0.02527260+0.00771167j)
    mode: Both
    model_param1: '3'
    model_param2: '2'
    model_param3: '3'
    model_param4: '2'
    model_param5: '1'
  states: {}
- name: dpd_GMP_model_PA_1
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (1.13009008-0.12616218j, -0.09705140+0.15224208j, -0.06966981-0.01212059j, -0.05285608-0.05305477j, 0.04687984-0.00207777j, 0.02600698+0.02553034j)
    coeff2: ( -0.07853527-0.00276647j, 0.08182787+0.0277548j, 0.09832700+0.026040201j, -0.06854425-0.02041091j, -0.04878962-0.01979666j, 0.02527260+0.00771167j)
    mode: Both
    model_param1: '3'
    model_param2: '2'
    model_param3: '3'
    model_param4: '2'
    model_param5: '1'
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    dpd_params: (3,2,3,2,1)
    mode: static
    tap: (0.87760033+0.12275496j, 0.08798957-0.14373307j, 0.04626261+0.00934458j, 0.08698256+0.04143527j, -0.03903108-0.00112882j, -0.03476379-0.00912934j, 0.08377796+0.02606456j, -0.08868867-0.04787423j, -0.10071640-0.04142282j, 0.05951364+0.03461860j, 0.04841621+0.02046442j, -0.02023946-0.01280763j)
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,0,4,1]'
    name: '"PA_without_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,1,4,1]'
    name: '"PA_with_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_PA_1, '0']
- [blocks_throttle_0, '0', dpd_predistorter_training_0, '0']
- [dpd_GMP_model_PA_0, '0', blocks_file_sink_0, '0']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_2, '0']
- [dpd_GMP_model_PA_1, '0', qtgui_freq_sink_x_1, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']

metadata:
  file_format: 1
