options:
  parameters:
    author: alekh
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: param_0
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1000'
    stop: '500000'
    value: '9000'
  states: {}
- name: param_1
  id: variable_qtgui_range
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Amplitude
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0.00075'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: param_1
    freq: param_0
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: param_1
    freq: '-param_0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dpd_GMP_model_PA_0
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (2.5+0.2j)
    coeff2: (1.3 + 2.4j, 2.1+3.0j, 1, 1, 1, 1, 1, 1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_GMP_model_PA_1
  id: dpd_GMP_model_PA
  parameters:
    coeff1: (2.5+0.2j)
    coeff2: (1.3 + 2.4j, 2.1+3.0j, 1,1,1,1,1,1)
    mode: Both
    model_param1: '1'
    model_param2: '1'
    model_param3: '2'
    model_param4: '2'
    model_param5: '2'
  states: {}
- name: dpd_LMS_postdistorter_0
  id: dpd_LMS_postdistorter
  parameters:
    dpd_params: (1,1,2,2,2)
    iter_limit: '1000'
    learning_rate: '0.75'
    method: newton
  states: {}
- name: dpd_gain_phase_calibrate_0
  id: dpd_gain_phase_calibrate
  parameters: {}
  states: {}
- name: dpd_predistorter_training_0
  id: dpd_predistorter_training
  parameters:
    dpd_params: (1,1,2,2,2)
    mode: training
    tap: (1)
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,0,4,1]'
    name: '"PA_without_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: '[1,1,4,1]'
    name: '"PA_with_DPD"'
    type: complex
    wintype: firdes.WIN_FLATTOP
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', dpd_GMP_model_PA_1, '0']
- [blocks_throttle_0, '0', dpd_gain_phase_calibrate_0, '1']
- [blocks_throttle_0, '0', dpd_predistorter_training_0, '0']
- [dpd_GMP_model_PA_0, '0', dpd_gain_phase_calibrate_0, '2']
- [dpd_GMP_model_PA_0, '0', qtgui_freq_sink_x_2, '0']
- [dpd_GMP_model_PA_1, '0', dpd_gain_phase_calibrate_0, '0']
- [dpd_GMP_model_PA_1, '0', qtgui_freq_sink_x_1, '0']
- [dpd_LMS_postdistorter_0, taps, dpd_predistorter_training_0, taps]
- [dpd_gain_phase_calibrate_0, '0', dpd_LMS_postdistorter_0, '0']
- [dpd_predistorter_training_0, '0', dpd_GMP_model_PA_0, '0']
- [dpd_predistorter_training_0, '0', dpd_LMS_postdistorter_0, '1']
- [dpd_predistorter_training_0, '1', dpd_LMS_postdistorter_0, '2']

metadata:
  file_format: 1
